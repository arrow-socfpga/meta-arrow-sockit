DESCRIPTION = "Arrow SoCKit GSRD init script customization"
AUTHOR = "Dan Negvesky <dnegvesky@arrow.com>"

#replace existing altera-gsrd-init.sh with sockit version
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"